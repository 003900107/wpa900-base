# Keil uVision project base_test.uvproj, settings and files
target base_test_flashmode (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: base_test +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_FULL_ASSERT,USE_STDPERIPH_DRIVER,CAN_APP,__CC_ARM,WATCHDOG
  c include: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS;..\user;..\BSP;..\STM32_ETH_Driver\inc;..\lwip-1.3.1\port\;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\efsl\include;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_cl.s stm32f10x.h system_stm32f10x.h
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c Realtimedb.c RTC_Time.c Proj_Config.h pad_client.c soe.c com_manager.c lwp103client.c 103com_func.c
  group bsp
    ../BSP/: bsp.c BaseBus_Protocol.c CanBus.c shellcmd.c tcp_modbus.c modbus.c I2CRoutines.c
    ../user/: netconf.c
  group ethlib
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group lwip
    ../lwip-1.3.1/src/netif/: etharp.c loopif.c slipif.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/port/: helloworld.c ethernetif.c server.c client.c
