# IAR project Base_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_CL; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS; ..\user; ..\BSP; ..\STM32_ETH_Driver\inc; ..\lwip-1.3.1\port\; ; ..\lwip-1.3.1\src\include; ..\lwip-1.3.1\src\include\ipv4; ..\lwip-1.3.1\src\include\lwip; ..\efsl\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Base_test.bin
  ILINK.IlinkOutputFile: Base_test.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group bsp
    ../BSP/: BaseBus_Protocol.c bsp.c CanBus.c I2CRoutines.c modbus.c shellcmd.c tcp_modbus.c
  group cmsis
    ../CMSIS/: core_cm3.c
    ./: startup_stm32f10x_cl.s
  group ethlib
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group lwip
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../lwip-1.3.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/port/: client.c ethernetif.c fsdata.c helloworld.c lwipopts.h server.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/netif/: etharp.c loopif.c slipif.c
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: 103com_func.c com_manager.c lwp103client.c main.c netconf.c pad_client.c Proj_Config.h Realtimedb.c RTC_Time.c soe.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
